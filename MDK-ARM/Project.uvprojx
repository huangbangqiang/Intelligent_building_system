# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../ioLibrary_Driver/Ethernet;../ioLibrary_Driver/Ethernet/W5300;../ioLibrary_Driver/Internet/DHCP;../ioLibrary_Driver/Internet/DNS;../ioLibrary_Driver/Internet/MQTT;../ioLibrary_Driver/Internet/MQTT/MQTTPacket/src;../user;../sensor;../lcd;../lcd/LCD;../lcd/SPI;../lcd/sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c fsmc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group dhcp
    ../ioLibrary_Driver/Internet/DHCP/: dhcp.c
  group dns
    ../ioLibrary_Driver/Internet/DNS/: dns.c
  group mqtt
    ../ioLibrary_Driver/Internet/MQTT/: mqtt_interface.c MQTTClient.c
    ../ioLibrary_Driver/Internet/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group w5300
    ../ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ../ioLibrary_Driver/Ethernet/W5300/: w5300.c
  group user
    ../user/: w5300_config.c HW_key.c bsp_flash.c cJSON.c
  group sensor
    ../sensor/: mq4.c relay.c
  group lcd
    ../lcd/LCD/: lcd.c
    ../lcd/SPI/: SPI.c
    ../lcd/sys/: sys.c
    ../lcd/: GUI.c ShowLCD.c
software components: CMSIS:CORE 4.3.0
